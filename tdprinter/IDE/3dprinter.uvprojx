# Keil uVision project 3dprinter.uvprojx, settings and files
target 3dprinter (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: 3dprinter
  AfterMake: fromelf --bin !L --output ../../3dprinter.bin
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: ..\;..\..\rt-thread\components\finsh;..\..\rt-thread\include;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m4;..\..\stm32f4xx_firmware\CMSIS\Include;..\..\stm32f4xx_firmware\CMSIS\DEVICE\ST\STM32F4xx\Include;..\..\stm32f4xx_firmware\STM32F4xx_StdPeriph_Driver\inc;..\..\RT-Thread\components\dfs\include;..\..\RT-Thread\components\dfs\filesystems\elmfat;..\..\RT-Thread\components\drivers\include;..\..\rt-thread\components\;..\..\stm32f4xx_firmware\STM32_USB_HOST_Library\Core\inc;..\..\stm32f4xx_firmware\STM32_USB_HOST_Library\Class\MSC\inc;..\..\stm32f4xx_firmware\STM32_USB_OTG_Driver\inc;..\bsp;..\..\RT-Thread\components\dfs\filesystems\
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_* --keep __rt_init*
  group app
    ../app/: app_3dprinter.c app_init.c app_retarget.c app_retarget.h app_subboard.c app_subboard.h app_subSystem.c cpuusage.c
  group bsp
    ../bsp/: bsp.c bsp.h bsp_config.h msd.c msd.h rtuart.c rtuart.h rtspi.c rtspi.h max6675.c max6675.h sddev.c sddev.h serial.c serial.h usb_bsp.c usbh_usr.c usbh_usr.h usbh_conf.h usb_conf.h usbmsc.c usbmsc.h nullromfs.c
  group core_fw
    ../../stm32f4xx_firmware/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../stm32f4xx_firmware/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../stm32f4xx_firmware/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group rt-thread
    ../../RT-Thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
    ../../RT-Thread/libcpu/arm/common/: div0.c showmem.c
    ../../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group finsh
    ../../RT-Thread/components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group config
    ../: rtconfig.h rtstartup.c stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
  group lib
    ../lib/: corePrinter.c corePrinter.h fakeDevice.c fakeDevice.h fileDevice.c fileDevice.h lib_lowpass.c lib_lowpass.h lib_pid.c lib_pid.h libConfig.c libConfig.h libStepAxis.c libStepAxis.h libStepBlock.c libStepBlock.h libStepGCode.c libStepGCode.h libStepGCodeProcessor.c libStepGCodeProcessor.h libStepMotor.c libStepMotor.h libStepPlanner.c libStepPlanner.h libStepPosition.c libStepPosition.h libStepTimer.c libStepTimer.h libTrigger.c libTrigger.h libYmodem.c libYmodem.h my_atof.c my_atof.h nullDevice.c nullDevice.h retarget.c retarget.h ringbuffer.c ringbuffer.h ringdata.c ringdata.h libPlanner.c libPlanner.h
  group stm32_drivers
    ../stm32f4_drivers/: drivers.c drivers.h gpio.c gpio.h iwdg.c iwdg.h spi.c spi.h systick.c systick.h tim_base.c tim_base.h tim_pwm.c tim_pwm.h uart.c uart.h uart_dma.c uart_dma.h drivers_config_brain.h drivers_config_TDP.h
  group componet frame
    ../../RT-Thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../RT-Thread/components/drivers/include/drivers/: spi.h
    ../../RT-Thread/components/init/: components.c components.h
  group lib_hmi
    ../lib/lib_hmi/: hmi_button.c hmi_button.h hmi_driver.c hmi_driver.h hmi_hal.c hmi_hal.h screen_main.c screen_main.h screen_main_printItem.c screen_main_status.c hmi_list.c hmi_list.h screen_dialog.c screen_config.c screen_config_sub.c
  group dfs
    ../../RT-Thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../RT-Thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ff.h ffconf.h integer.h
    ../../RT-Thread/components/dfs/filesystems/elmfat/option/: cc936.c
    ../../RT-Thread/components/dfs/filesystems/romfs/: dfs_romfs.c dfs_romfs.h
  group param
    ../lib/param/: interface.h param.c param.h
  group usb_fw
    ../../stm32f4xx_firmware/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../stm32f4xx_firmware/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../../stm32f4xx_firmware/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_core.c usbh_msc_bot.c usbh_msc_scsi.c
target 3dprinter-brain (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  cpu: as above
  output: 3dprinter
  AfterMake: fromelf --bin !L --output ../3dprinter.bin
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: .;..\rt-thread\components\finsh;..\rt-thread\include;..\rt-thread\libcpu\arm\common;..\rt-thread\libcpu\arm\cortex-m4;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\DEVICE\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\RT-Thread\components\dfs\include;..\RT-Thread\components\dfs\filesystems\elmfat;..\RT-Thread\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_* --keep __rt_init*
